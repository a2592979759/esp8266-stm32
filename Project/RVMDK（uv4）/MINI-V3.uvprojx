# Keil uVision project MINI-V3.uvprojx, settings and files
target rc522 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rc522 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\SysTick;..\..\User\RC522;..\..\User\lcd;..\..\User\ADC;..\..\User\BH1750;..\..\User\ds18b20;..\..\User\dwt_delay;..\..\User\EXTI;..\..\User\KEY;..\..\User\LED;..\..\User\TIMER;..\..\User\usart;..\..\User\sys;..\..\User\delay;..\..\User\beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/RC522/: rc522_config.c rc522_function.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c bsp_lcd.c
    ../../User/ADC/: adc.c
    ../../User/BH1750/: bh1750.c
    ../../User/ds18b20/: bsp_ds18b20.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/EXTI/: exti.c
    ../../User/KEY/: key.c
    ../../User/LED/: led.c
    ../../User/TIMER/: timer.c
    ../../User/usart/: bsp_usart.c
    ../../User/delay/: delay.c
    ../../User/sys/: sys.c
    ../../User/beep/: bsp_beep.c
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 4.3.0
